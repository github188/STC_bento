# Keil uVision project EV_STC_DVR_V1.0.uvproj, settings and files
target EV_STC_DVR_V1.0 (MCS-51)
  device: 8xC151SB Intel
  cpu: IRAM(0-0xFF) CLOCK(16000000)
  output: EV_STC_DVR_V1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\API;.\Driver
  group APP
    ./APP/: main.c
  group API
    ./API/: API_Bento.c
  group Driver
    ./Driver/: board.c timer.c uart1.c uart2.c RS485.c
  group Startup
    ./: STARTUP.A51
